<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32WB55ADV-Tester.ewp</path>
  </project>
  <batchBuild />
</workspace>
